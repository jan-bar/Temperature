# Keil uVision project WENDU.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: WENDU +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.a51 AMPIRE128X64.a51 DS18B20.a51 DS1302.a51 FM24C64.a51
